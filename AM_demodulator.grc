options:
  parameters:
    author: Carolina Mata
    generate_options: qt_gui
    id: AM_demodulator
    output_language: python
    title: AM demodulador
  states: {}

blocks:
- name: fc
  id: variable_qtgui_range
  parameters:
    start: 16e3
    step: 1e3
    stop: 100e3
    value: 32e3
  states: {}
- name: fm
  id: variable
  parameters:
    value: 32e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fc
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/teocom_jue/CaroTdC/practic2ç/AM_modulated_4kHz_sin.dat
    repeat: 'True'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: 200e3
    type: float
  states: {}
- name: dc_blocker_xx_1
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [blocks_file_source_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [dc_blocker_xx_1, '0', blocks_throttle2_0, '0']
- [low_pass_filter_0, '0', dc_blocker_xx_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
